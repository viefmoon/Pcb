# Repository viefmoon/Pcb

## EAGLE design mega.brd

Parts:
ATMEGA2560: ATMEGA2560; TQFP100
BLUE: L; SMD-0805-LED
C1: CAPACITOR-SMD-0805; SMD-0805
C2, C3, C4: .1uF; SMD-0805
ORANGE: L; SMD-0805-LED
R1, R2, R3: 10k; SMD-0805
SCHOTTKY: DIODE; SOD-323
XTAL: 16M; RESONATOR

Connections:
2: ATMEGA2560.6 ((OC3B/INT4)PE4)
3: ATMEGA2560.7 ((OC3C/INT5)PE5)
4: ATMEGA2560.1 ((OC0B)PG5)
5: ATMEGA2560.5 ((OC3A/AIN1)PE3)
5V: ATMEGA2560.10 (VCC), ATMEGA2560.31 (VCC1), ATMEGA2560.61 (VCC2), ATMEGA2560.80 (VCC3), ATMEGA2560.100 (AVCC), BLUE.1 (A), C1.1, C2.1, C3.1, R3.2, SCHOTTKY.C
6: ATMEGA2560.15 (PH3(OC4A))
7: ATMEGA2560.16 (PH4(OC4B))
8: ATMEGA2560.17 (PH5(OC4C))
9: ATMEGA2560.18 (PH6(OC2B))
10: ATMEGA2560.23 ((OC2A/PCINT4)PB4)
11: ATMEGA2560.24 ((OC1A/PCINT5)PB5)
12: ATMEGA2560.25 ((OC1B/PCINT6)PB6)
13: ATMEGA2560.26 ((OC0A/OC1C/PCINT7)PB7), ORANGE.1 (A)
20: ATMEGA2560.44 ((SDA/INT1)PD1)
21: ATMEGA2560.43 ((SCL/INT0)PD0)
22: ATMEGA2560.78 ((AD0)PA0)
23: ATMEGA2560.77 ((AD1)PA1)
24: ATMEGA2560.76 ((AD2)PA2)
25: ATMEGA2560.75 ((AD3)PA3)
26: ATMEGA2560.74 ((AD4)PA4)
27: ATMEGA2560.73 ((AD5)PA5)
28: ATMEGA2560.72 ((AD6)PA6)
29: ATMEGA2560.71 ((AD7)PA7)
30: ATMEGA2560.60 ((A15)PC7)
31: ATMEGA2560.59 ((A14)PC6)
32: ATMEGA2560.58 ((A13)PC5)
33: ATMEGA2560.57 ((A12)PC4)
34: ATMEGA2560.56 ((A11)PC3)
35: ATMEGA2560.55 ((A10)PC2)
36: ATMEGA2560.54 ((A9)PC1)
37: ATMEGA2560.53 ((A8)PC0)
38: ATMEGA2560.50 ((T0)PD7)
39: ATMEGA2560.70 ((ALE)PG2)
40: ATMEGA2560.52 ((RD)PG1)
41: ATMEGA2560.51 ((WR)PG0)
42: ATMEGA2560.42 (PL7)
43: ATMEGA2560.41 (PL6)
44: ATMEGA2560.40 (PL5(OC5C))
45: ATMEGA2560.39 (PL4(OC5B))
46: ATMEGA2560.38 (PL3(OC5A))
47: ATMEGA2560.37 (PL2(T5))
48: ATMEGA2560.36 (PL1(ICP5))
49: ATMEGA2560.35 (PL0(ICP4))
50: ATMEGA2560.22 ((MISO/PCINT3)PB3)
51: ATMEGA2560.21 ((MOSI/PCINT2)PB2)
52: ATMEGA2560.20 ((SCK/PCINT1)PB1)
53: ATMEGA2560.19 ((SS/PCINT0)PB0)
A0: ATMEGA2560.97 ((ADC0)PF0)
A1: ATMEGA2560.96 ((ADC1)PF1)
A2: ATMEGA2560.95 ((ADC2)PF2)
A3: ATMEGA2560.94 ((ADC3)PF3)
A4: ATMEGA2560.93 ((ADC4/TCK)PF4)
A5: ATMEGA2560.92 ((ADC5/TMS)PF5)
A6: ATMEGA2560.91 ((ADC6/TDO)PF6)
A7: ATMEGA2560.90 ((ADC7/TDI)PF7)
A8: ATMEGA2560.89 (PK0(ADC8/PCINT16))
A9: ATMEGA2560.88 (PK1(ADC9/PCINT17))
A10: ATMEGA2560.87 (PK2(ADC10/PCINT18))
A11: ATMEGA2560.86 (PK3(ADC11/PCINT19))
A12: ATMEGA2560.85 (PK4(ADC12/PCINT20))
A13: ATMEGA2560.84 (PK5(ADC13/PCINT21))
A14: ATMEGA2560.83 (PK6(ADC14/PCINT22))
A15: ATMEGA2560.82 (PK7(ADC15/PCINT23))
AREF: ATMEGA2560.98 (AREF)
DTR: C4.2
GND: ATMEGA2560.11 (GND), ATMEGA2560.32 (GND1), ATMEGA2560.62 (GND2), ATMEGA2560.81 (GND3), ATMEGA2560.99 (AGND), C1.2, C2.2, C3.2, R1.1, R2.1, XTAL.2
unnamed: ATMEGA2560.34 (XTAL1), XTAL.3
unnamed: ATMEGA2560.33 (XTAL2), XTAL.1
unnamed: ORANGE.2 (C), R1.2
unnamed: BLUE.2 (C), R2.2
RST: ATMEGA2560.30 (RESET), C4.1, R3.1
RX0: ATMEGA2560.2 ((RXD0/PCIN8)PE0)
RX1: ATMEGA2560.45 ((RXD1/INT2)PD2)
RX2: ATMEGA2560.12 (PH0(RXD2))
RX3: ATMEGA2560.63 (PJ0(RXD3/PCINT9))
TX0: ATMEGA2560.3 ((TXD0)PE1)
TX1: ATMEGA2560.46 ((TXD1/INT3)PD3)
TX2: ATMEGA2560.13 (PH1(TXD2))
TX3: ATMEGA2560.64 (PJ1(TXD3/PCINT10))
VUSB: SCHOTTKY.A

Notes on the sheet:
.1uF

Board: 2 copper layers, 159.6 x 99.6 mm, 12 parts (0 on the bottom side), 8 nets.
